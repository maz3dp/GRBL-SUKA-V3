# Keil uVision project GRBL-SUKA-V3.uvprojx, settings and files
target GRBL-SUKA-V3 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GRBL-SUKA-V3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Src; ..\Src\grbl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group GRBL
    ../Src/grbl/: config.h coolant_control.c coolant_control.h cpu_map.h defaults.h eeprom.c eeprom.h gcode.c gcode.h grbl.h jog.c jog.h limits.c limits.h main.c motion_control.c motion_control.h nuts_bolts.c nuts_bolts.h planner.c planner.h print.c print.h probe.c probe.h protocol.c protocol.h report.c report.h serial.c serial.h settings.c settings.h spindle_control.c spindle_control.h stepper.c stepper.h system.c system.h
  group Application/User
    ../Src/: porting.c porting.h main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Inc/: main.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
